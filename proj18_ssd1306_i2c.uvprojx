# Keil uVision project proj18_ssd1306_i2c.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: proj18_ssd1306_i2c
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: i2c.c i2c.h main.c ssd1306.c ssd1306.h systick.c systick.h font.c bmp.c mpu6050.c mpu6050.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
